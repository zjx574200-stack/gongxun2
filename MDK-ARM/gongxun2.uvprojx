# Keil uVision project gongxun2.uvprojx, settings and files
target gongxun2 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: gongxun2 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;   ../Drivers/STM32F4xx_HAL_Driver/Inc;   ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;   ../Drivers/CMSIS/Include;   ..\APP;   ..\zujianku;   ..\zujianku\ebtn;   ..\zujianku\ringbuffer;   ..\APP\sensor_app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ../Core/Inc/: dma.h gpio.h main.h stm32f4xx_hal_conf.h stm32f4xx_it.h usart.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group APP
    ../APP/ebtn_app/: ebtn_app.c ebtn_app.h
    ../APP/ioout_app/: ioout_app.c ioout_app.h
    ../APP/pt_app/: pt_app.c pt_app.h
    ../APP/usart12_app/: usart12_app.c usart12_app.h
    ../APP/zdt_motor/: zdt_motor.c zdt_motor.h zdt_motor_port.c zdt_motor_port.h
    ../APP/conveyor_app/: conveyor_app.c conveyor_app.h
    ../APP/: mydefine.h sequencer.c sequencer.h
    ../APP/sensor_app/: sensor.c sensor.h
    ../APP/servo/: servo.c servo.h servo_port.c servo_port.h servo_hw_test.c servo_hw_test.h
    ../APP/turntable_app/: turntable_app.c turntable_app.h
    ../APP/vision_app/: vision_app.c vision_app.h
    ../APP/oled_app/: oled_app.c oled_app.h
    ../APP/screen_app/: screen_app.c screen_app.h
  group zujianku
    ../zujianku/ebtn/: bit_array.h ebtn.c ebtn.h
    ../zujianku/ringbuffer/: ringbuffer.c ringbuffer.h
    ../zujianku/: pt.h
software components: CMSIS:CORE 4.3.0
